# IAR project Project.ewp, settings and files
configuration STM32F429ZI_NUCLEO_144 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; USE_STM32F4XX_NUCLEO_144; __ICCARM__; EI_PORTING_IAR
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo_144; IarProjectConnection/model-parameters; IarProjectConnection/tflite-model; IarProjectConnection; IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Include; IarProjectConnection/edge-impulse-sdk/CMSIS/Core/Include; IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: STM32F429ZI_Nucleo_144.hex
  ILINK.IlinkOutputFile: STM32F429ZI_Nucleo_144.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    IarProjectConnection/: edge_impulse.ipcf
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F4xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c
  group Edge Impulse/Classifier
    IarProjectConnection/edge-impulse-sdk/classifier/: ei_run_classifier.h
  group Edge Impulse/CMSIS
    IarProjectConnection/edge-impulse-sdk/CMSIS/Core/Include/: cmsis_iccarm.h
  group Edge Impulse/CMSIS/DSP/BasicMathFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_and_u16.c arm_and_u32.c arm_and_u8.c arm_clip_f16.c arm_clip_f32.c arm_clip_q15.c arm_clip_q31.c arm_clip_q7.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_not_u16.c arm_not_u32.c arm_not_u8.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_or_u16.c arm_or_u32.c arm_or_u8.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c arm_xor_u16.c arm_xor_u32.c arm_xor_u8.c
  group Edge Impulse/CMSIS/DSP/BayesFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/BayesFunctions/: arm_gaussian_naive_bayes_predict_f16.c arm_gaussian_naive_bayes_predict_f32.c
  group Edge Impulse/CMSIS/DSP/CommonTables
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c
  group Edge Impulse/CMSIS/DSP/ComplexMathFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f16.c arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f16.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f16.c arm_cmplx_mag_f32.c arm_cmplx_mag_f64.c arm_cmplx_mag_fast_q15.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f16.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_f64.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f16.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_f64.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f16.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group Edge Impulse/CMSIS/DSP/ControllerFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group Edge Impulse/CMSIS/DSP/DistanceFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/DistanceFunctions/: arm_boolean_distance.c arm_braycurtis_distance_f16.c arm_braycurtis_distance_f32.c arm_canberra_distance_f16.c arm_canberra_distance_f32.c arm_chebyshev_distance_f16.c arm_chebyshev_distance_f32.c arm_chebyshev_distance_f64.c arm_cityblock_distance_f16.c arm_cityblock_distance_f32.c arm_cityblock_distance_f64.c arm_correlation_distance_f16.c arm_correlation_distance_f32.c arm_cosine_distance_f16.c arm_cosine_distance_f32.c arm_cosine_distance_f64.c arm_dice_distance.c arm_euclidean_distance_f16.c arm_euclidean_distance_f32.c arm_euclidean_distance_f64.c arm_hamming_distance.c arm_jaccard_distance.c arm_jensenshannon_distance_f16.c arm_jensenshannon_distance_f32.c arm_kulsinski_distance.c arm_minkowski_distance_f16.c arm_minkowski_distance_f32.c arm_rogerstanimoto_distance.c arm_russellrao_distance.c arm_sokalmichener_distance.c arm_sokalsneath_distance.c arm_yule_distance.c
  group Edge Impulse/CMSIS/DSP/FastMathFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/FastMathFunctions/: arm_atan2_f32.c arm_atan2_q15.c arm_atan2_q31.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_divide_q15.c arm_divide_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c
  group Edge Impulse/CMSIS/DSP/MatrixFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/MatrixFunctions/: arm_householder_f16.c arm_householder_f32.c arm_householder_f64.c arm_mat_add_f16.c arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cholesky_f16.c arm_mat_cholesky_f32.c arm_mat_cholesky_f64.c arm_mat_cmplx_mult_f16.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_cmplx_trans_f16.c arm_mat_cmplx_trans_f32.c arm_mat_cmplx_trans_q15.c arm_mat_cmplx_trans_q31.c arm_mat_init_f16.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f16.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_ldlt_f32.c arm_mat_ldlt_f64.c arm_mat_mult_f16.c arm_mat_mult_f32.c arm_mat_mult_f64.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_opt_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_q7.c arm_mat_qr_f16.c arm_mat_qr_f32.c arm_mat_qr_f64.c arm_mat_scale_f16.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_solve_lower_triangular_f16.c arm_mat_solve_lower_triangular_f32.c arm_mat_solve_lower_triangular_f64.c arm_mat_solve_upper_triangular_f16.c arm_mat_solve_upper_triangular_f32.c arm_mat_solve_upper_triangular_f64.c arm_mat_sub_f16.c arm_mat_sub_f32.c arm_mat_sub_f64.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f16.c arm_mat_trans_f32.c arm_mat_trans_f64.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_q7.c arm_mat_vec_mult_f16.c arm_mat_vec_mult_f32.c arm_mat_vec_mult_q15.c arm_mat_vec_mult_q31.c arm_mat_vec_mult_q7.c
  group Edge Impulse/CMSIS/DSP/QuaternionMathFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/QuaternionMathFunctions/: arm_quaternion2rotation_f32.c arm_quaternion_conjugate_f32.c arm_quaternion_inverse_f32.c arm_quaternion_norm_f32.c arm_quaternion_normalize_f32.c arm_quaternion_product_f32.c arm_quaternion_product_single_f32.c arm_rotation2quaternion_f32.c
  group Edge Impulse/CMSIS/DSP/StatisticsFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/StatisticsFunctions/: arm_absmax_f16.c arm_absmax_f32.c arm_absmax_f64.c arm_absmax_no_idx_f16.c arm_absmax_no_idx_f32.c arm_absmax_no_idx_f64.c arm_absmax_no_idx_q15.c arm_absmax_no_idx_q31.c arm_absmax_no_idx_q7.c arm_absmax_q15.c arm_absmax_q31.c arm_absmax_q7.c arm_absmin_f16.c arm_absmin_f32.c arm_absmin_f64.c arm_absmin_no_idx_f16.c arm_absmin_no_idx_f32.c arm_absmin_no_idx_f64.c arm_absmin_no_idx_q15.c arm_absmin_no_idx_q31.c arm_absmin_no_idx_q7.c arm_absmin_q15.c arm_absmin_q31.c arm_absmin_q7.c arm_accumulate_f16.c arm_accumulate_f32.c arm_accumulate_f64.c arm_entropy_f16.c arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f16.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f16.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f16.c arm_logsumexp_f32.c arm_max_f16.c arm_max_f32.c arm_max_f64.c arm_max_no_idx_f16.c arm_max_no_idx_f32.c arm_max_no_idx_f64.c arm_max_no_idx_q15.c arm_max_no_idx_q31.c arm_max_no_idx_q7.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f16.c arm_mean_f32.c arm_mean_f64.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f16.c arm_min_f32.c arm_min_f64.c arm_min_no_idx_f16.c arm_min_no_idx_f32.c arm_min_no_idx_f64.c arm_min_no_idx_q15.c arm_min_no_idx_q31.c arm_min_no_idx_q7.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_mse_f16.c arm_mse_f32.c arm_mse_f64.c arm_mse_q15.c arm_mse_q31.c arm_mse_q7.c arm_power_f16.c arm_power_f32.c arm_power_f64.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f16.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f16.c arm_std_f32.c arm_std_f64.c arm_std_q15.c arm_std_q31.c arm_var_f16.c arm_var_f32.c arm_var_f64.c arm_var_q15.c arm_var_q31.c
  group Edge Impulse/CMSIS/DSP/SupportFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/SupportFunctions/: arm_barycenter_f16.c arm_barycenter_f32.c arm_bitonic_sort_f32.c arm_bubble_sort_f32.c arm_copy_f16.c arm_copy_f32.c arm_copy_f64.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_f16_to_float.c arm_f16_to_q15.c arm_fill_f16.c arm_fill_f32.c arm_fill_f64.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_f16.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_heap_sort_f32.c arm_insertion_sort_f32.c arm_merge_sort_f32.c arm_merge_sort_init_f32.c arm_q15_to_f16.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_quick_sort_f32.c arm_selection_sort_f32.c arm_sort_f32.c arm_sort_init_f32.c arm_weighted_sum_f16.c arm_weighted_sum_f32.c
  group Edge Impulse/CMSIS/DSP/SVMFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/SVMFunctions/: arm_svm_linear_init_f16.c arm_svm_linear_init_f32.c arm_svm_linear_predict_f16.c arm_svm_linear_predict_f32.c arm_svm_polynomial_init_f16.c arm_svm_polynomial_init_f32.c arm_svm_polynomial_predict_f16.c arm_svm_polynomial_predict_f32.c arm_svm_rbf_init_f16.c arm_svm_rbf_init_f32.c arm_svm_rbf_predict_f16.c arm_svm_rbf_predict_f32.c arm_svm_sigmoid_init_f16.c arm_svm_sigmoid_init_f32.c arm_svm_sigmoid_predict_f16.c arm_svm_sigmoid_predict_f32.c
  group Edge Impulse/CMSIS/DSP/TransformFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_bitreversal_f16.c arm_cfft_f16.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f16.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f16.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f16.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f16.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f16.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_mfcc_f16.c arm_mfcc_f32.c arm_mfcc_init_f16.c arm_mfcc_init_f32.c arm_mfcc_init_q15.c arm_mfcc_init_q31.c arm_mfcc_q15.c arm_mfcc_q31.c arm_rfft_f32.c arm_rfft_fast_f16.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f16.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group Edge Impulse/CMSIS/NN/ActivationFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
  group Edge Impulse/CMSIS/NN/BasicMathFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s8.c
  group Edge Impulse/CMSIS/NN/ConcatenationFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
  group Edge Impulse/CMSIS/NN/ConvolutionFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_fast_s16.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_wrapper_s16.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_fast_s16.c arm_depthwise_conv_s16.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s16.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_s8.c
  group Edge Impulse/CMSIS/NN/FullyConnectedFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7_opt.c arm_fully_connected_s16.c arm_fully_connected_s8.c
  group Edge Impulse/CMSIS/NN/NNSupportFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
  group Edge Impulse/CMSIS/NN/PoolingFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s16.c arm_max_pool_s8.c arm_pool_q7_HWC.c
  group Edge Impulse/CMSIS/NN/ReshapeFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group Edge Impulse/CMSIS/NN/SoftmaxFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s16.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group Edge Impulse/CMSIS/NN/SVDFunctions
    IarProjectConnection/edge-impulse-sdk/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c
  group Edge Impulse/dsp
    IarProjectConnection/edge-impulse-sdk/dsp/: memory.cpp
  group Edge Impulse/dsp/dct
    IarProjectConnection/edge-impulse-sdk/dsp/dct/: fast-dct-fft.cpp
  group Edge Impulse/dsp/image
    IarProjectConnection/edge-impulse-sdk/dsp/image/: processing.cpp
  group Edge Impulse/dsp/kissfft
    IarProjectConnection/edge-impulse-sdk/dsp/kissfft/: kiss_fft.cpp kiss_fftr.cpp
  group Edge Impulse/Porting
    IarProjectConnection/edge-impulse-sdk/porting/iar/: ei_classifier_porting.cpp
  group Edge Impulse/Tensorflow/c
    IarProjectConnection/edge-impulse-sdk/tensorflow/lite/c/: common.c
  group Edge Impulse/Tensorflow/core
    IarProjectConnection/edge-impulse-sdk/tensorflow/lite/core/api/: common.cc error_reporter.cc flatbuffer_conversions.cc op_resolver.cc tensor_utils.cc
  group Edge Impulse/Tensorflow/kernels
    IarProjectConnection/edge-impulse-sdk/tensorflow/lite/kernels/: kernel_util_lite.cc tree_ensemble_classifier.cc
    IarProjectConnection/edge-impulse-sdk/tensorflow/lite/kernels/internal/: portable_tensor_utils.cc quantization_util.cc reference_portable_tensor_utils.cc tensor_utils.cc
  group Edge Impulse/Tensorflow/micro
    IarProjectConnection/edge-impulse-sdk/tensorflow/lite/micro/kernels/: activations.cc activations_common.cc add.cc add_common.cc add_n.cc arg_min_max.cc assign_variable.cc batch_matmul.cc batch_to_space_nd.cc broadcast_args.cc broadcast_to.cc call_once.cc cast.cc ceil.cc circular_buffer.cc circular_buffer_common.cc comparisons.cc complex_abs.cc concatenation.cc conv.cc conv_common.cc cumsum.cc depth_to_space.cc depthwise_conv.cc depthwise_conv_common.cc dequantize.cc dequantize_common.cc detection_postprocess.cc div.cc elementwise.cc elu.cc ethosu.cc exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc fully_connected.cc fully_connected_common.cc gather.cc gather_nd.cc hard_swish.cc hard_swish_common.cc if.cc kernel_runner.cc kernel_util_micro.cc l2_pool_2d.cc l2norm.cc leaky_relu.cc leaky_relu_common.cc log_softmax.cc logical.cc logical_common.cc logistic.cc logistic_common.cc lstm_eval.cc maximum_minimum.cc micro_tensor_utils.cc mirror_pad.cc mli_interface.cc mli_slicers.cc mul.cc mul_common.cc neg.cc pack.cc pad.cc pooling.cc pooling_common.cc prelu.cc prelu_common.cc quantize.cc quantize_common.cc read_variable.cc real.cc reduce.cc reduce_common.cc reshape.cc resize_bilinear.cc resize_nearest_neighbor.cc rfft2d.cc round.cc scratch_buf_mgr.cc scratch_buffers.cc select.cc shape.cc slice.cc softmax.cc softmax_common.cc space_to_batch_nd.cc space_to_depth.cc split.cc split_v.cc squared_difference.cc squeeze.cc strided_slice.cc sub.cc sub_common.cc svdf.cc svdf_common.cc tanh.cc transpose.cc transpose_conv.cc tree_ensemble_classifier.cc unidirectional_sequence_lstm.cc unpack.cc var_handle.cc while.cc zeros_like.cc
    IarProjectConnection/edge-impulse-sdk/tensorflow/lite/micro/: all_ops_resolver.cc fake_micro_context.cc flatbuffer_conversions_bridge.cc flatbuffer_utils.cc memory_helpers.cc micro_allocation_info.cc micro_allocator.cc micro_context.cc micro_error_reporter.cc micro_graph.cc micro_interpreter.cc micro_log.cc micro_profiler.cc micro_resource_variable.cc micro_string.cc micro_time.cc micro_utils.cc mock_micro_graph.cc non_persistent_arena_buffer_allocator.cc op_resolver_bridge.cc persistent_arena_buffer_allocator.cc recording_micro_allocator.cc recording_single_arena_buffer_allocator.cc schema_utils.cc single_arena_buffer_allocator.cc system_setup.cc test_helper_custom_ops.cc test_helpers.cc
    IarProjectConnection/edge-impulse-sdk/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc non_persistent_buffer_planner_shim.cc
  group Edge Impulse/tflite-model
    IarProjectConnection/tflite-model/: tflite_learn_27_compiled.cpp
  group Example/EWARM
    ./: startup_stm32f429xx.s
  group Example/User
    ../Src/: ei_main.cpp main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
